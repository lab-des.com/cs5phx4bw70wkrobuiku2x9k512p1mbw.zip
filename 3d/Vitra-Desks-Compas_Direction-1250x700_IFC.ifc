Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-10-19T20:41:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 19 20:41:51 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{FBC34E57-6E6C-43C7-AB99-3FF97DC7B660}\ifc * Database version: 5507 * Database creation date: Wed Oct 19 20:41:50 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 19 20:41:50 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 19 20:41:50 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Compas Direction - 1250x700, Vitra-Desks-Compas_Direction:Compas Direction - 1250x700:426670
In: Level 1
Type - Material: Dark oak with protective vanish, Japanese red powder-coated (smooth)
Type - Construction - TableType: Compas_Direction_1250x700
Type - Dimensions - NominalDepth: 700 mm; NominalHeight: 730 mm; NominalLength: 1250 mm
Type - General - Author: BIMstone; BIMObjectName: Vitra-Desks-Compas_Direction; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 28/09/2022
Type - Identity Data - Cost: 0; Description: The slender, elegantly splayed legs of Compas Direction, designed by Jean Prouvé in 1953, call to mind the hinged arms of a compass – 'le compas' in French. With its compact dimensions, the desk is ideal for the contemporary home office.; Designer: Jean Prouvé; Manufacturer: Vitra; Model: Compas Direction - 1250x700; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Compas Direction - 1250x700; URL: https://www.vitra.com/living/product/details/compas-direction
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Desks-Compas_Direction; Features: n/a; Finish: Table top: solid wood in natural oak with oiled finish, dark stained oak with protective natural lacquer finish, or American walnut with oiled finish. Base: bent sheet steel, powder-coated finish (smooth). Origin of wood: oak (Quercus robur) from Western Europe and/or Poland; American walnut (Juglans nigra) from the USA.; Grade: n/a; Material: Metal; ModelNumber: n/a; ModelReference: n/a; Name: Compas_Direction; ReplacementCost: n/a; Shape: Sculptured; Size: 1250x700x730 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 2.2985 m2; Volume: 0.63875 m3
Materials and Finishes - BaseMaterial: Japanese red powder-coated (smooth); TableTopMaterial: Dark oak with protective vanish
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Desks-Compas_Direction: Compas Direction - 1250x700; Family and Type: Vitra-Desks-Compas_Direction: Compas Direction - 1250x700; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Desks-Compas_Direction: Compas Direction - 1250x700; Type Id: Vitra-Desks-Compas_Direction: Compas Direction - 1250x700; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
